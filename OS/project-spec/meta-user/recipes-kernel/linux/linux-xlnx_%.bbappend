SRC_URI += "file://user_2019-06-15-13-57-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

